# Keil uVision project SolarDetector_OLED.uvprojx, settings and files
target SolarDetector_OLED (6070000::V6.7::.\ARMCLANG)
  device: STM32G031F8Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(16000000) ELITTLE
  output: solar_detector_oled +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G031xx,DISPLAY_TFT=0
  c misc: -std=c11 -Wall -Wextra
  c include: ..\Inc;..\Vendor
  asm define: __MICROLIB
  asm include: ..\Vendor
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\memory.sct
  group Application
    ../Src/: board.c sensor.c display.c main.c
  group Startup
    ../Vendor/: startup_stm32g031xx.s
